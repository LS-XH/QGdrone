# Keil uVision project ACFly.uvprojx, settings and files
target Target 1 (6140000::V6.14::.\ARMCompiler6.14)
  device: STM32H743VITx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.1.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00100000) IROM2(0x08100000,0x00100000) XRAM(0x30000000,0x00048000) XRAM2(0x38000000,0x00010000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: ACFly +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=6 v6LangP=4 wLevel=3
  c define: USE_HAL_DRIVER,STM32H743xx,ARM_MATH_CM7,__FPU_PRESENT=1,DCACHE_SIZE=32,SYSFREQ480
  c include: .\Basic;.\Main;.\CMSIS;.\HAL_Library\inc;.\FreeRTOS\include;.\FreeRTOS\portable\RVDS\ARM_CM7\r0p1;.\FreeRTOS\CMSIS_RTOS;.\Drivers;.\Drivers\extIO;.\USBDevice;.\USBDevice\Core\Inc;.\USBDevice\Class\CDC\Inc;.\Math;.\CMSIS\DSP\Include;.\FatFs\src;.\FatFs\src\option;.\Communication;.\MeasurementSystem;.\Filters;.\DataStructure;.\Communication\Mavlink;.\Communication\Mavlink\commonACFly;.\Modes;.\ControlSystem;.\littlefs;.\littlefs\bd;.\Communication\Mavlink\minimalACFly
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x8100000 size 0x100000
  memory RVCT6: RAM 0x30000000 size 0x48000
  memory RVCT7: RAM 0x38000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  scatter file: .\Objects\ACFly_Prophet.sct
  group Main
    ./Main/: main.cpp
  group Basic
    ./Basic/: Parameters.hpp StorageSystem.hpp Missions.hpp Basic.cpp TimeBase.cpp InternalStorage.cpp SDStorage.cpp Parameters.cpp GUI.cpp GUI_Images.cpp Font.cpp Missions.cpp Fences.cpp sha256.c followTarget.cpp precLand.cpp dgtPwm.cpp hitTarget.cpp
  group Startup
    ./startup/: startup_stm32h743xx.s
  group CMSIS
    ./CMSIS/: system_stm32h7xx.c
  group HAL_Library
    ./HAL_Library/src/: stm32h7xx_hal.c stm32h7xx_hal_msp.c stm32h7xx_hal_cortex.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_pcd.c stm32h7xx_hal_pcd_ex.c stm32h7xx_ll_usb.c stm32h7xx_ll_delayblock.c stm32h7xx_ll_sdmmc.c stm32h7xx_hal_sd.c stm32h7xx_hal_sd_ex.c stm32h7xx_hal_fdcan.c
    ./HAL_Library/inc/: stm32h7xx_hal_conf.h
  group FreeRTOS
    ./FreeRTOS/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c static_mem.c cpu_load.cpp
    ./FreeRTOS/portable/MemMang/: heap_4.c
    ./FreeRTOS/portable/RVDS/ARM_CM7/r0p1/: port.c
    ./FreeRTOS/CMSIS_RTOS/: cmsis_os.c
  group Drivers
    ./Drivers/: Sensors.hpp SensorsBackend.hpp Receiver.hpp ReceiverBackend.hpp Sensors.cpp Receiver.cpp drv_Main.cpp drv_Sensors.cpp drv_LED.cpp drv_USB.cpp drv_Uart1.cpp drv_Uart3.cpp drv_Uart5.cpp drv_Uart7.cpp drv_Uart8.cpp drv_SDMMC.cpp drv_PWMOut.cpp drv_Flash.cpp drv_RCSbus.cpp drv_RCPPM.cpp drv_Oled.cpp drv_Ultrasonic.cpp drv_SDI.cpp drv_ADC.cpp drv_ExtIIC.cpp drv_Can.cpp drv_CRC.cpp
  group Drivers\ExtIO
    ./Drivers/extIO/: drv_extIO_HTL.cpp
  group UartDrivers
    ./Drivers/: drv_GPS.cpp drv_RTK.cpp drv_RTK_DAO_Base.cpp drv_RTK_DAO_Move.cpp drv_UM482.cpp drv_UM982.cpp drv_UM982_movingTrack.cpp drv_MosaxicX5.cpp drv_MosaxicX6.cpp drv_TFMini.cpp drv_TFMiniAv.cpp drv_UWB_LinkTrack.cpp drv_OpticalFlow_JL32xx.cpp drv_OpticalFlow_LC302.cpp drv_OpticalFlow_LC306.cpp drv_OpticalFlow_GL9306.cpp drv_UsbForwarding.cpp drv_MR72_UartAv.cpp drv_NRA24.cpp drv_ISTRA24.cpp drv_YT_ZR10.cpp drv_YT_INYYO.cpp drv_YT_RYEOP.cpp drv_YT_Viewlink.cpp drv_ISTRA24_2.cpp drv_US100.cpp drv_CRSF.cpp drv_GPS_nmea.cpp drv_OpticalFlow_T1_T2.cpp drv_GPS1_UbloxM10.cpp
  group I2cDrivers
    ./Drivers/: drv_InternalMag.cpp drv_ExtMag.cpp drv_ExtLed_TCA62724FMG.cpp drv_ExtBarometer.cpp drv_IICTFMini_Av.cpp drv_IIC_Ina226.cpp
  group CanDrivers
    ./Drivers/: drv_CAN_BMS_TATTU.cpp drv_CAN_MR72_Av.cpp drv_CAN_QOAR1271_Av.cpp drv_CAN_Radar_TR60_AH.cpp drv_CAN_Hobbywing_ESC.cpp
  group LittleFs
    ./littlefs/: lfs.c lfs_util.c
  group FatFs
    ./FatFs/src/: bsp_driver_sd.c diskio.c fatfs.c ff.c sd_diskio.c flash_diskio.c ff_gen_drv.c ffunicode.c ffsystem.c
  group Math
    ./Math/: AC_Math.hpp vector2.hpp vector3.hpp quaternion.hpp map_projection.hpp smooth_kp.hpp math_common_tables.cpp
  group Communication
    ./Communication/: Commulink.hpp Debug.cpp Commulink.cpp Mavlink.cpp MavlinkCMDProcess.cpp MavlinkSendFuncs.cpp MavlinkRCProcess.cpp
  group MeasurementSystem
    ./MeasurementSystem/: MeasurementSystem.hpp MS_Main.cpp MeasurementSystem.lib
  group Filters
    ./Filters/: TD4.hpp TD3_3D.hpp Filters_LP.hpp Filters_BS.hpp
  group DataStructure
    ./DataStructure/: RingQueue.hpp
  group Modes
    ./Modes/: NavCmdProcess.hpp InFlightCmdProcess.hpp Modes.cpp M10_RCCalib.cpp M11_TempCalib.cpp M12_AccCalib.cpp M13_MagCalib.cpp M14_HorizonCalib.cpp M30_AttCtrl.cpp M32_PosCtrl.cpp M35_Auto1.cpp MSafe.cpp NavCmdProcess.cpp InFlightCmdProcess.cpp AuxFuncs.cpp Avoidance.cpp
  group ControlSystem
    ./ControlSystem/: ControlSystem.hpp ESO_AngularRate.hpp ESO_h.hpp ctrl_Main.cpp Ctrl_Attitude.cpp ctrl_Position.cpp
